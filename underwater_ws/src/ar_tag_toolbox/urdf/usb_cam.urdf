Commit message: Lots of AR Stuff

File: underwater_ws/src/ar_tag_toolbox/urdf/usb_cam.urdf (robot description, URDF)
Before this commit: robot usb_cam, 2 links, 1 joints
Links:
- removed link base_link
- added link camera_base_link
